# Repository Ricsi1231/BLDC-motor-controller-Hardware (continued)

## KiCad design BLDC motor controller/BLDC motor controller.kicad_pcb (continued)

Schematic: Interface - RS8485.kicad_sch

Parts:
C1701: 4u7 16V X7R; C_0603_1608Metric; Manufacturer Part Number GRM188Z71C475KE21D
C1702: 100n 16V X7R; C_0402_1005Metric; Manufacturer Part Number C1005X7R1C104K050BC
R1701, R1702: 10k 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2F1002X
R1703, R1705: 390R 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2D3900X
R1704: 120R; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2D1200X
U1701: SP3494; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer Part Number SP3494EN-L

Connections:
+3V3: C1701.1, C1702.1, R1701.1, R1703.1, U1701.8 (VSS); also elsewhere on the board
/Project Architecture/Interface - Interconnects/RS485_N: R1704.2, R1705.1, U1701.7 (B); also elsewhere on the board
/Project Architecture/Interface - Interconnects/RS485_P: R1703.2, R1704.1, U1701.6 (A); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_DE: R1701.2, U1701.3 (DE); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_N: U1701.1 (RO); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_P: U1701.4 (DI); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_nRE: R1702.1, U1701.2 (nRE); also elsewhere on the board
GND: C1701.2, C1702.2, R1702.2, R1705.2, U1701.5 (GND); also elsewhere on the board

Notes on the sheet:
[${#}] Interface - RS8485
LAYOUT NOTE: Place close to RS485 connector.
UART - RS485 Half Duplex Inteface

Schematic: MCU - PWR.kicad_sch

Parts:
C801: 1u 16V X7R; C_0603_1608Metric; Manufacturer Part Number EMK107B7105KA8T
C802, C807, C808, C810: 4u7 16V X7R; C_0603_1608Metric; Manufacturer Part Number GRM188Z71C475KE21D
C803, C804, C805, C806, C809, C811: 100n 16V X7R; C_0402_1005Metric; Manufacturer Part Number C1005X7R1C104K050BC
FB801: 1k @100MHz; L_0805_2012Metric; Manufacturer Part Number ACML-0805H-102-T
U801_901: STM32G474RET6; QFP50P1200X1200X160-64N; Manufacturer Part Number STM32G474RET6

Connections:
+3V3: C801.1, C802.1, C803.1, C804.1, C805.1, C806.1, U801_901.1 (VBAT), U801_901.15 (VDD), U801_901.32 (VDD), U801_901.48 (VDD), U801_901.64 (VDD); also elsewhere on the board
+3V3A: C807.1, FB801.1; also elsewhere on the board
+3V3A_FILT: C808.1, C809.1, C810.1, C811.1, FB801.2, U801_901.28 (VREF+), U801_901.29 (VDDA)
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, C811.2, U801_901.16 (VSS), U801_901.27 (VSSA), U801_901.31 (VSS), U801_901.47 (VSS), U801_901.63 (VSS); also elsewhere on the board

Notes on the sheet:
LAYOUT NOTE: Place all cpaacitors to relevant pin. Minimize loop inductance.
[${#}] MCU - PWR
Microcontroller Power Supply Scheme

Schematic: MCU - I_O.kicad_sch, MCU - I/O

Parts:
R901: 10k 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-PA3F1002V
TP901, TP902, TP903, TP904, TP905, TP906, TP907, TP908, TP909, TP910, TP911, TP912, TP913: AUX; TestPoint_Pad_1.0x1.0mm
TP914, TP915, TP916, TP917, TP918, TP919, TP920, TP921, TP922, TP923, TP924, TP925, TP926: DRIVER; TestPoint_Pad_D1.0mm
TP927, TP928: TEMP; TestPoint_Pad_1.0x1.0mm
TP929: BATEERY; TestPoint_Pad_1.0x1.0mm
TP930, TP931, TP932, TP933: FD_CAN; TestPoint_Pad_1.0x1.0mm
TP934, TP935, TP936, TP937: RS485; TestPoint_Pad_1.0x1.0mm
TP938: FAN; TestPoint_Pad_1.0x1.0mm
TP939, TP940, TP941: HAL; TestPoint_Pad_D1.0mm
U801_901: STM32G474RET6; QFP50P1200X1200X160-64N; Manufacturer Part Number STM32G474RET6

Connections:
/Project Architecture/Interface - FD-CAN/CAN_MCU_N: TP931.1, U801_901.45 (PA11); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_MCU_P: TP930.1, U801_901.46 (PA12); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_S: TP933.1, U801_901.41 (PC9); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_SHDN: TP932.1, U801_901.40 (PC8); also elsewhere on the board
/Project Architecture/Interface - Fan Control/FAN_CONTROL_IN: TP938.1, U801_901.11 (PC3); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_A: TP906.1, U801_901.57 (PB4); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_B: TP905.1, U801_901.58 (PB5); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_CS: TP910.1, U801_901.51 (PA15); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_I: TP904.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_MISO: TP908.1, U801_901.52 (PC10); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_MOSI: TP909.1, U801_901.53 (PC11); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_SCK: TP907.1, U801_901.54 (PC12); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_U: TP903.1, U801_901.59 (PB6); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_V: TP902.1, U801_901.55 (PD2); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_W: TP901.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_2_PWM: TP911.1, U801_901.62 (PB9); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_2_SCL: TP912.1, U801_901.43 (PA9); also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_2_SDA: TP913.1, U801_901.42 (PA8); also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWCLK: U801_901.50 (PA14); also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWDIO: U801_901.49 (PA13); also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWO: U801_901.56 (PB3); also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_nRESET: U801_901.7 (PG10); also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_A: TP939.1, U801_901.39 (PC7); also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_B: TP940.1, U801_901.38 (PC6); also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_C: TP941.1, U801_901.37 (PB15); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_DE: TP934.1, U801_901.13 (PA1); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_N: TP936.1, U801_901.17 (PA3); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_P: TP937.1, U801_901.14 (PA2); also elsewhere on the board
/Project Architecture/Interface - RS8485/RS485_UART_nRE: TP935.1, U801_901.12 (PA0); also elsewhere on the board
/Project Architecture/MCU - I_O/BATTERY_VSENSE: TP929.1, U801_901.9 (PC1); also elsewhere on the board
/Project Architecture/MCU - I_O/BOARD_VERSION: U801_901.5 (PF0); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_CS: TP921.1, U801_901.18 (PA4); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_ENABLE: TP926.1, U801_901.22 (PC4); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_HIZ: TP917.1, U801_901.23 (PC5); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_MISO: TP919.1, U801_901.20 (PA6); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_MOSI: TP918.1, U801_901.21 (PA7); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_NFALUT: TP925.1, U801_901.30 (PB10); also elsewhere on the board
/Project Architecture/MCU - I_O/DRIVER_SCK: TP920.1, U801_901.19 (PA5); also elsewhere on the board
/Project Architecture/MCU - I_O/FILTERED_SOA: TP922.1, U801_901.33 (PB11); also elsewhere on the board
/Project Architecture/MCU - I_O/FILTERED_SOB: TP923.1, U801_901.34 (PB12); also elsewhere on the board
/Project Architecture/MCU - I_O/FILTERED_SOC: TP924.1, U801_901.35 (PB13); also elsewhere on the board
/Project Architecture/MCU - I_O/LED_DBG_1: U801_901.3 (PC14); also elsewhere on the board
/Project Architecture/MCU - I_O/LED_DBG_2: U801_901.4 (PC15); also elsewhere on the board
/Project Architecture/MCU - I_O/MCU_BOOT: R901.2, U801_901.61 (PB8)
/Project Architecture/MCU - I_O/PWM_PHASE_A: TP916.1, U801_901.24 (PB0); also elsewhere on the board
/Project Architecture/MCU - I_O/PWM_PHASE_B: TP915.1, U801_901.25 (PB1); also elsewhere on the board
/Project Architecture/MCU - I_O/PWM_PHASE_C: TP914.1, U801_901.26 (PB2); also elsewhere on the board
/Project Architecture/MCU - I_O/SENSE_TEMP_FET: TP928.1, U801_901.10 (PC2); also elsewhere on the board
/Project Architecture/MCU - I_O/SENSE_TEMP_MOT: TP927.1, U801_901.8 (PC0); also elsewhere on the board
GND: R901.1; also elsewhere on the board

Notes on the sheet:
Shunt outputs filtered
Half bridge PWMs
Do not forget flash optlon bytes when flashing for the first time.
Temperature Sense Connection
Auxiliary port 1
BOOT Pin Configuration
[${#}] MCU - I/O
Fan Control Connection
RS485 Connection
Battery Sense Connection
Debug Led's
Connection to Gate Driver
SWD Debug/Programming
SPI for DRV config
Auxiliary port 2
External Enocder
Motor enable and fault
FD-CAN Connection
Test Points
Microcontroller I/O Pins
Auxiliary Ports
Board Version

Schematic: Interface - Interconnects.kicad_sch

Parts:
C2001, C2003, C2009, C2011, C2015, C2024: 4u7 16V X7R; C_0603_1608Metric; Manufacturer Part Number GRM188Z71C475KE21D
C2002, C2004, C2010, C2012, C2016, C2022: 100n 16V X7R; C_0402_1005Metric; Manufacturer Part Number C1005X7R1C104K050BC
C2005, C2006, C2007, C2008, C2013, C2014, C2021, C2023, C2025: DNP; C_0603_1608Metric; not fitted
C2017: 2u2 100V X7R; C_0805_2012Metric; Manufacturer Part Number CGA4J1X7R2A225K125AC
C2018: 100n 100V X7R; C_0603_1608Metric; Manufacturer Part Number KAF15BR72A104KT
D1403, D1404, D1405: BAT41KFILM; D_SOD-523; Manufacturer Part Number BAT41KFILM
D2001, D2004: ESDR0524SMUTAG; Manufacturer Part Number ESDR0524SMUTAG
D2002, D2003, D2005, D2006: DF3A5.6LFU,LF; SOT-23-3; Manufacturer Part Number DF3A5.6LFU,LF
D2007: CG0402MLC-3.3LG; D_0402_1005Metric; Manufacturer Part Number CG0402MLC-3.3LG
D2009, D2010, D2011: CG0402MLC-12G; D_0402_1005Metric; Manufacturer Part Number CG0402MLC-12LG
J2001: Conn_01x07; Molex_PicoBlade_53048-0710_1x07_P1.25mm_Horizontal; Manufacturer Part Number 53048-0710
J2004, J2005, J2008, J2009: Conn_01x03; Molex_PicoBlade_53048-0310_1x03_P1.25mm_Horizontal; Manufacturer Part Number 53048-0310
J2007: Conn_ARM_SWD_TagConnect_TC2030-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J2011, J2012: Conn_01x02; Molex_PicoBlade_53048-0210_1x02_P1.25mm_Horizontal; Manufacturer Part Number 53048-0210
J2202: Conn_01x05; Molex_PicoBlade_53048-0510_1x05_P1.25mm_Horizontal; Manufacturer Part Number 53048-0510
J2203: Conn_01x05; Molex_PicoBlade_53261-0571_1x05-1MP_P1.25mm_Horizontal; Manufacturer Part Number 53261-0571
R1903, R1904, R1905: 10k 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-PA3F1002V
R2001, R2002, R2003, R2004, R2006, R2007, R2010, R2012, R2013: 100R 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-UP3F1000V
R2008, R2009, R2011, R20010: 22R 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2F22R0X

Connections:
+3V3: C2003.1, C2004.1, C2011.1, C2012.1, C2015.1, C2016.1, D1403.1 (K), D1404.1 (K), D1405.1 (K), J2001.1, J2007.1 (VCC), J2202.1, R1903.2, R1904.2, R1905.2; also elsewhere on the board
+5V: C2001.1, C2002.1, C2009.1, C2010.1, C2022.1, C2024.1, J2001.2, J2202.2, J2203.1; also elsewhere on the board
+12V: C2017.1, C2018.1, J2012.2; also elsewhere on the board
/Project Architecture/Interface - FD-CAN/FDCAN_N: D2003.1 (K), J2004.3, J2005.1; also elsewhere on the board
/Project Architecture/Interface - FD-CAN/FDCAN_P: D2003.2 (K), J2004.1, J2005.3; also elsewhere on the board
/Project Architecture/Interface - Fan Control/FAN_CONTROL_PWM: D2007.1 (K), J2012.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUXP_1_CS: D2001.5 (K), J2001.3, R2001.2
/Project Architecture/Interface - Interconnects/AUXP_1_MISO: D2001.4, J2001.4, R2002.2
/Project Architecture/Interface - Interconnects/AUXP_1_MOSI: D2001.2, J2001.5, R2003.2
/Project Architecture/Interface - Interconnects/AUXP_1_SCK: D2001.1 (K), J2001.6, R2004.2
/Project Architecture/Interface - Interconnects/AUXP_2_SCL: D2002.2 (K), J2202.4, R2007.2
/Project Architecture/Interface - Interconnects/AUXP_2_SDA: D2002.1 (K), J2202.3, R2006.2
/Project Architecture/Interface - Interconnects/AUX_1_CS: C2005.1, R2001.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_MISO: C2006.1, R2002.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_MOSI: C2007.1, R2003.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_1_SCK: C2008.1, R2004.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_2_SCL: C2013.1, R2007.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/AUX_2_SDA: C2014.1, R2006.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWCLK: R2009.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWDIO: R20010.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_SWO: R2011.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/MCU_nRESET: R2008.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_A: C2025.1, D1405.2 (A), R1903.1, R2010.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_A_P: D2010.1 (K), J2203.2, R2010.2
/Project Architecture/Interface - Interconnects/POSITON_B: C2023.1, D1404.2 (A), R1904.1, R2012.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_B_P: D2009.1 (K), J2203.3, R2012.2
/Project Architecture/Interface - Interconnects/POSITON_C: C2021.1, D1403.2 (A), R1905.1, R2013.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/POSITON_C_P: D2011.1 (K), J2203.4, R2013.2
/Project Architecture/Interface - Interconnects/RS485_N: D2005.1 (K), J2008.3, J2009.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/RS485_P: D2005.2 (K), J2008.1, J2009.3; also elsewhere on the board
/Project Architecture/Interface - Interconnects/SWCLK: D2004.2, J2007.4 (SWCLK), R2009.2
/Project Architecture/Interface - Interconnects/SWDIO: D2004.4, J2007.2 (SWDIO), R20010.2
/Project Architecture/Interface - Interconnects/SWO: D2004.1 (K), J2007.6 (SWO), R2011.2
/Project Architecture/Interface - Interconnects/TEMP_MOT_H: D2006.2 (K), J2011.2; also elsewhere on the board
/Project Architecture/Interface - Interconnects/TEMP_MOT_L: D2006.1 (K), J2011.1; also elsewhere on the board
/Project Architecture/Interface - Interconnects/nRESET: D2004.5 (K), J2007.3 (~RESET), R2008.2
GND: C2001.2, C2002.2, C2003.2, C2004.2, C2005.2, C2006.2, C2007.2, C2008.2, C2009.2, C2010.2, C2011.2, C2012.2, C2013.2, C2014.2, C2015.2, C2016.2, C2017.2, C2018.2, C2021.2, C2022.2, C2023.2, C2024.2, C2025.2, D2001.3, D2002.3 (A), D2003.3 (A), D2004.3, D2005.3 (A), D2006.3 (A), D2007.2 (A), D2009.2 (A), D2010.2 (A), D2011.2 (A), J2001.7, J2004.2, J2005.2, J2007.5 (GND), J2008.2, J2009.2, J2202.5, J2203.5; also elsewhere on the board

Notes on the sheet:
LAYOUT NOTE: Place filter near to connector
DESIGN NOTE: Optinally popiulate capacitors if excessive noise seen on the pins.
DESIGN NOTE: Only connect GND if connected device does not share ground!
12V Fan Connector
[${#}] Interface - Interconnects
DESIGN NOTE: Do not exceed maximum ratings for pin voltages!
Motor Temperature Sensing Thermistor Connector
SWD Debug/Programming Inzerface
Auxilliary Connector AUX1
Auxilliary Connector AUX2
LAYOUT NOTE: FDCAN should be routed as a 120-ohm differential pair.
FD CAN Connector
RS485 Connector
LAYOUT NOTE: FDCAN should be routed as a 100-ohm differential pair.
DESIGN NOTE: Ideally connect thermistor with nominal B-Constant 4050-4099K.
HAL Sensor Connector

Schematic: Interface - FD-CAN.kicad_sch, Sheet Title B

Parts:
C1703, C1801: 4u7 16V X7R; C_0603_1608Metric; Manufacturer Part Number GRM188Z71C475KE21D
C1802: 100n 16V X7R; C_0402_1005Metric; Manufacturer Part Number C1005X7R1C104K050BC
R1801, R1802: 10k 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2F1002X
R1803, R1804: 60R4 1% 1/4W; R_0603_1608Metric; Manufacturer Part Number ERJ-UP3F60R4V
SW2001: CAS-220TA; SW_DPDT_CK_JS202011JCQN; Manufacturer Part Number CAS-220TA
U1801: TCAN330; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer Part Number TCAN330GDR

Connections:
+3V3: C1801.1, C1802.1, U1801.3 (VCC); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_MCU_N: U1801.4 (RXD); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_MCU_P: U1801.1 (TXD); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_S: R1801.1, U1801.8 (S); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/CAN_SHDN: R1802.1, U1801.5 (SHDN); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/FDCAN_N: R1804.2, SW2001.3 (C); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/FDCAN_P: R1803.1, SW2001.6 (C); also elsewhere on the board
/Project Architecture/Interface - FD-CAN/FDCAN_TERM_MID: C1703.1, R1803.2, R1804.1
/Project Architecture/Interface - FD-CAN/FDCAN_TN: SW2001.2 (B), U1801.6 (CANL)
/Project Architecture/Interface - FD-CAN/FDCAN_TP: SW2001.5 (B), U1801.7 (CANH)
GND: C1703.2, C1801.2, C1802.2, R1801.2, R1802.2, U1801.2 (GND); also elsewhere on the board

Notes on the sheet:
Flexible I/O worked examples
References:
Flexible I/O source configuration
High Speed FD-CAN Transiver
[${#}] Interface - FD-CAN
LAYOUT NOTE: Place close to FDCAN connector.
DESIGN NOTE: Silent mode and Shutdown are disabled.

Schematic: Motor Control - Inverter - Phase B.kicad_sch

Parts:
C1201, C1202: 22n 100V X7R; C_0805_2012Metric; Manufacturer Part Number KAM21BR72A223KM
C1203: 100n 100V X7R; C_1206_3216Metric; Manufacturer Part Number 885382208006
C1204: 10u 100V X7R; C_1210_3225Metric; Manufacturer Part Number C3225X7R2A106K250AC
D1201, D1202, D1203: BAT41KFILM; D_SOD-523; Manufacturer Part Number BAT41KFILM
J1201: PHASE_B; Pad_Square_Vias_6.5x6.5mm
NT1201, NT1202, NT1203: DIFF_PAIR; NetTie-2_SMD_Pad0.5mm
Q1201, Q1202: TPW1R306PL,L1Q; SOP_ADVANCE; Manufacturer Part Number TPW1R306PL,L1Q
R1201, R1202: 7R5 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-U03F7R50V
R1203: 0m5 1% 2W; R_2512_6332Metric; Manufacturer Part Number PA2512FKE7W0R005E
R1204, R1205: 22R 1%; R_0805_2012Metric; Manufacturer Part Number ERJ-6ENF22R0V

Connections:
+VBAT_SAFE: C1203.1, C1204.1, Q1201.1 (D), R1204.1; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase A/DRIVER_GHB: D1201.1 (K), R1201.1; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase A/DRIVER_GLB: D1202.1 (K), R1202.1; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase A/DRIVER_SHB: NT1201.2; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase A/DRIVER_SPB+: NT1202.2; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase A/DRIVER_SPB-: NT1203.2; also elsewhere on the board
/Project Architecture/Motor Control - Inverter - Phase B/FET_GHB: D1201.2 (A), Q1201.2 (G), R1201.2
/Project Architecture/Motor Control - Inverter - Phase B/FET_GLB: D1202.2 (A), D1203.1 (K), Q1202.2 (G), R1202.2
/Project Architecture/Motor Control - Inverter - Phase B/PHASE_B: C1201.2, J1201.1, NT1201.1, Q1201.3 (S), Q1202.1 (D), R1205.1
/Project Architecture/Motor Control - Inverter - Phase B/PHASE_B_S: C1202.2, C1203.2, NT1202.1, Q1202.3 (S), R1203.1
GND: C1204.2, D1203.2 (A), NT1203.1, R1203.2; also elsewhere on the board
unnamed: C1201.1, R1204.2
unnamed: C1202.1, R1205.2

Notes on the sheet:
Flexible I/O worked examples
References:
Flexible I/O source configuration
Inverter Phase B
DESIGN NOTE: Optional RC snubber to reduce ringing.
DESIGN NOTE: Local bulk and negative bounce tone sppression capacitors.
[12] Motor Control - Inverter - Phase B
DESIGN NOTE: Gate resistor + dischrage diode.
DESIGN NOTE: Low-Side Schottky diodes protect FET's gate against negavtive transients.

Schematic: Power Generation - Buck Converter.kicad_sch

Parts:
C601, C602, C603, C609, C610, C611, C617, C618: 2u2 100V X7R; C_1210_3225Metric; Manufacturer Part Number C1210C225J1RACAUTO
C604, C606, C612, C614, C620: 100n 100V X7R; C_0805_2012Metric; Manufacturer Part Number 08051C104JAZ2A
C605, C613: 1u 50V X7R; C_0805_2012Metric; Manufacturer Part Number 08055C105JAT2A
C607, C615: 22u 25V X7R; C_1210_3225Metric; Manufacturer Part Number MSAST32MSB7226KPNB25
C608, C616: 100n 25V X7R; C_0603_1608Metric; Manufacturer Part Number C0603C104J3RECAUTO7411
C619: 10u 25V X7R; C_1210_3225Metric; Manufacturer Part Number GRM32DR71E106KA12K
C622: 22u 16V X7R; C_1210_3225Metric; Manufacturer Part Number MSAST32MSB7226KPNB25
C623: 100n 25V X7R; C_0805_2012Metric; Manufacturer Part Number 08053C104KAZ2A
F603: 1k @100MHz; L_0805_2012Metric; Manufacturer Part Number ACML-0805H-102-T
FB601, FB602: 1k @100MHz; L_0805_2012Metric; Manufacturer Part Number ACML-0805H-102-T
L601, L602: 22u; L_Coilcraft_LPS4018; Manufacturer Part Number LPS4018-223MRC
L603: 2u2; L_Coilcraft_LPS3314; Manufacturer Part Number LPS3314-222MRC
NT601: FB_5V; NetTie-2_SMD_Pad0.5mm
NT602: EN_3V3; NetTie-2_SMD_Pad0.5mm
NT603: VOS_3V3; NetTie-2_SMD_Pad0.5mm
NT604: FB_3V3; NetTie-2_SMD_Pad0.5mm
R601, R605: 140k 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-PA3F1403V
R602, R604, R606, R608, R611: 10k 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-PA3F1002V
R603, R607: 0R; R_0603_1608Metric; Manufacturer Part Number ERJ-H3G0R00V
R609: 100k 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-UP3F1003V
R610: 9k9 1%; R_0603_1608Metric; Manufacturer Part Number ERJ-UP3F9531V
TP601, TP602, TP603: +VBAT; TestPoint_Pad_1.0x1.0mm
TP604: VIN_3V3; TestPoint_Pad_1.0x1.0mm
TP605: VIN_5V; TestPoint_Pad_1.0x1.0mm
TP606: VIN_12V; TestPoint_Pad_1.0x1.0mm
TP607, TP608: +12V; TestPoint_Pad_1.0x1.0mm
TP609, TP610: +5V; TestPoint_Pad_1.0x1.0mm
TP611, TP612: +3V3; TestPoint_Pad_1.0x1.0mm
TP613, TP614, TP615: GND; TestPoint_Pad_1.0x1.0mm
U601: LMR36506MSC5RPERQ1; Manufacturer Part Number LMR36506MSC5RPERQ1
U602: LMR36506MSCQRPERQ1; LMR36506MSC5RPERQ1; Manufacturer Part Number LMR36506MSCQRPERQ1
U603: TPS62172; SON50P200X200X80-9N; Manufacturer Part Number TPS62172QDSGRQ1

Connections:
+3V3: C622.1, C623.1, L603.2, NT603.1, R611.1, TP611.1, TP612.1; also elsewhere on the board
+5V: C607.1, C608.1, C617.1, F603.1, L601.2, NT601.2, R604.1, TP609.1, TP610.1; also elsewhere on the board
+12V: C615.1, C616.1, L602.2, R608.1, R609.1, TP607.1, TP608.1; also elsewhere on the board
+VBAT_FILT_3V3_IN: C618.1, C619.1, C620.1, F603.2, NT602.1, TP604.1, U603.2 (VIN)
+VBAT_FILT_5V_IN: C602.1, C603.1, C604.1, FB601.2, R601.1, TP605.1, U601.4 (VIN)
+VBAT_FILT_12V_IN: C610.1, C611.1, C612.1, FB602.2, R605.1, TP606.1, U602.4 (VIN)
+VBAT_SAFE: C601.1, C609.1, FB601.1, FB602.1, TP601.1, TP602.1, TP603.1; also elsewhere on the board
/Project Architecture/Power Generation - Buck Converter/BUCK_3V3_ENABLE: NT602.2, U603.3 (EN)
/Project Architecture/Power Generation - Buck Converter/BUCK_3V3_FB: NT604.2, U603.5 (FB)
/Project Architecture/Power Generation - Buck Converter/BUCK_3V3_PG: R611.2, U603.8 (PGOOD)
/Project Architecture/Power Generation - Buck Converter/BUCK_3V3_SW: L603.1, U603.7 (SW)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_BOOT: C606.1, U601.6 (BOOT)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_ENABLE: R601.2, R602.1, U601.3 (EN/UVLO)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_FB: NT601.1, U601.8 (FB)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_MODE: R603.1, U601.1 (SYNC/MODE)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_PG: R604.2, U601.2 (PGOOD)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_SW: C606.2, L601.1, U601.5 (SW)
/Project Architecture/Power Generation - Buck Converter/BUCK_5V_VCC: C605.1, U601.7 (VCC)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_BOOT: C614.1, U602.6 (BOOT)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_ENABLE: R605.2, R606.1, U602.3 (EN/UVLO)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_FB: R609.2, R610.1, U602.8 (FB)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_MODE: R607.1, U602.1 (SYNC/MODE)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_PG: R608.2, U602.2 (PGOOD)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_SW: C614.2, L602.1, U602.5 (SW)
/Project Architecture/Power Generation - Buck Converter/BUCK_12V_VCC: C613.1, U602.7 (VCC)
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C607.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C615.2, C616.2, C617.2, C618.2, C619.2, C620.2, C622.2, C623.2, NT604.1, R602.2, R603.2, R606.2, R607.2, R610.2, TP613.1, TP614.1, TP615.1, U601.9 (GND), U602.9 (GND), U603.1 (PGND), U603.4 (AGND), U603.9 (PAD); also elsewhere on the board
unnamed: NT603.2, U603.6 (VOS)

Notes on the sheet:
+12V - Fan Power +5V - Gate Driver, Led +3V3 - Digital 3V3
3.3V 500mA Buck Regulator (2.25 MHz)
Ground
Test Points
[${#}] Power Generation - Buck Converter
DESIGN NOTE: MODE = LOW - Auto mode.
LAYOUT NOTE: Minimize switching node loop areas.
Filtered Input Power Rails
LAYOUT NOTE: Route feedback traces away from switching node.
DESIGN NOTE: L = (VIN - VOUT) * VOUT / Fsw * k * VIN Computed with: VIN = 0V, k = 0,15, VOUT = 5V, IOUT = 600mA
12V 600mA Buck Regulator (2.1 MHz)
Battery
Power Rails
Voltage Regulators
5V 600mA Buck Regulator (2.1 MHz)

Schematic: Power Generation - LDO.kicad_sch

Parts:
C701: 2u2 16V X7R; C_0805_2012Metric; Manufacturer Part Number C0805C225K4RAC3123
C702, C703: 100n 25V X7R; C_0805_2012Metric; Manufacturer Part Number 08053C104KAZ2A
C704: 4u7 16V X7R; C_0805_2012Metric; Manufacturer Part Number C0805C475K4RAC7210
NT701: LDO_EN; NetTie-2_SMD_Pad0.5mm
TP701, TP702: +3V3A; TestPoint_Pad_1.0x1.0mm
TP703, TP704: GND; TestPoint_Pad_1.0x1.0mm
U701: LP2992; SOT-23-5; Manufacturer Part Number LP2992AILDX-3.3/NOPB

Connections:
+3V3A: C704.1, TP701.1, TP702.1, U701.5 (VOUT); also elsewhere on the board
+5V: C701.1, C702.1, NT701.1, U701.1 (VIN); also elsewhere on the board
/Project Architecture/Power Generation - LDO/LDO_BYPASS: C703.1, U701.4 (BYPASS)
/Project Architecture/Power Generation - LDO/LDO_EN: NT701.2, U701.3 (EN)
GND: C701.2, C702.2, C703.2, C704.2, TP703.1, TP704.1, U701.2 (GND); also elsewhere on the board

Notes on the sheet:
+3V3A - Analouge 3V3
Voltage Regulator
[${#}] Power Generation - LDO
Test Points
LAYOUT NOTE: Place all cpaacitors to relevant pin. Minimize loop inductance.
+3V3 250mA Linear Regulator
Power Rails
Ground

Schematic: Power Generation - Bulk Capacitors.kicad_sch

Parts:
C501, C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C533, C534, C535, C536, C537, C538, C539, C540, C541, C542: 10u 100V X7R; C_1210_3225Metric; Manufacturer Part Number C3225X7R2A106K250AC

Connections:
+VBAT_SAFE: C501.1, C502.1, C503.1, C504.1, C505.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C513.1, C514.1, C515.1, C516.1, C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, C523.1, C524.1, C525.1, C526.1, C527.1, C528.1, C529.1, C530.1, C531.1, C532.1, C533.1, C534.1, C535.1, C536.1, C537.1, C538.1, C539.1, C540.1, C541.1, C542.1; also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.2, C532.2, C533.2, C534.2, C535.2, C536.2, C537.2, C538.2, C539.2, C540.2, C541.2, C542.2; also elsewhere on the board

Notes on the sheet:
DESIGN NOTE: An external precharge ciruit is advised to charge bulk capacitors. If multiple boards are connected.
Bulk Capacitors 14 x 4.7 = 197.4 uF
[${#}] Power Generation - Bulk Capacitors
